options:
  parameters:
    category: Custom
    description: Transmit a pre-defined signal (a complex sine) as OFDM packets.
    generate_options: qt_gui
    id: ofdm_loopback_example
    output_language: python
    title: OFDM Loopback Example
  states: {}

blocks:
- name: alg
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '2'
    step_size: '.0001'
    type: cma
  states: {}
- name: corr_calc
  id: variable
  parameters:
    value: corr_thresh/(corr_max*corr_max)
  states: {}
- name: corr_max
  id: variable
  parameters:
    value: numpy.abs(numpy.dot(modulated_sync_word,numpy.conj(modulated_sync_word)))
  states: {}
- name: corr_thresh
  id: variable_qtgui_range
  parameters:
    label: Absolute Corr Thresh (Mag Sq)
    start: '0.1'
    step: '1.0'
    stop: 5e6
    value: 1e6
  states: {}
- name: data
  id: variable
  parameters:
    value: '[0]*4+[random.getrandbits(8) for i in range(payload_size)]'
  states: {}
- name: eb
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '1260000000'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '.001'
  states: {}
- name: modulated_sync_word
  id: variable
  parameters:
    comment: |-
      Note that the modulated sync word
      as generated by Modulate Vector
      block has some filtering transients.

      Offset to the beginning of the 
      actual preamble
    value: modulated_sync_word_pre[86:(512+86)]
  states: {}
- name: modulated_sync_word_pre
  id: variable_modulate_vector
  parameters:
    data: ' preamble+preamble'
    mod: rxmod
    taps: '[1]'
  states: {}
- name: num_taps
  id: variable
  parameters:
    value: '64'
  states: {}
- name: payload_size
  id: variable
  parameters:
    value: '100'
  states: {}
- name: phase
  id: variable_qtgui_range
  parameters:
    label: phase
    start: '0.00'
    step: '.1'
    stop: '3.14'
    value: '0'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: '[0x27,0x2F,0x18,0x5D,0x5B,0x2A,0x3F,0x71,0x63,0x3C,0x17,0x0C,0x0A,0x41,0xD6,0x1F,0x4C,0x23,0x65,0x68,0xED,0x1C,0x77,0xA7,0x0E,0x0A,0x9E,0x47,0x82,0xA4,0x57,0x24,]'
  states: {}
- name: preamble_symbols
  id: variable
  parameters:
    value: helpers.map_symbols_to_constellation(helpers.unpack_values(preamble, 8, 2), qpsk)
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    comment: |-
      Symbol Map: [0,1,3,2] <- This is Gray coding
      Constellation Points: [-0.707-0.707j, 0.707-0.707j, +0.707+0.707j, -0.707+0.707j]
    const_points: '[-0.707-0.707j, 0.707-0.707j, +0.707+0.707j, -0.707+0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rxmod
  id: variable
  parameters:
    value: digital.generic_mod(qpsk, False, sps, True, eb, False, False)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_int_0
  id: blocks_float_to_int
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0_0
  id: digital_linear_equalizer
  parameters:
    alg: alg
    num_taps: num_taps
    sps: '1'
    training_sequence: '[]'
    training_start_tag: '""'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    comment: Gray coding
    map: '[0,1,3,2]'
  states: {}
- name: digital_probe_mpsk_snr_est_c_0
  id: digital_probe_mpsk_snr_est_c
  parameters:
    alpha: '0.001'
    msg_nsamples: '1000000'
    type: '2'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_ZERO_CROSSING
    type: cc
  states: {}
- name: helpers
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph


      def unpack_values(values_in, bits_per_value, bits_per_symbol):   
          # verify that 8 is divisible by bits_per_symbol 
          m = bits_per_value / bits_per_symbol
          # print(m)
          mask = 2**(bits_per_symbol)-1
              
          if bits_per_value != m*bits_per_symbol:
              print("error - bits per symbols must fit nicely into bits_per_value bit values")
              return []
              
          num_values = len(values_in)
          # print(num_values)
          num_symbols = int(num_values*( m) )
          # print(num_symbols)
          cur_byte = 0
          cur_bit = 0
          out = []
          for i in range(num_symbols):
              s = (values_in[cur_byte] >> (bits_per_value-bits_per_symbol-cur_bit)) & mask
              out.append(s)
              cur_bit += bits_per_symbol
              
              if cur_bit >= bits_per_value:
                  cur_bit = 0
                  cur_byte += 1
                  
              # if cur_byte >= num_values:
                  # break;
                  
          return out
          
      def map_symbols_to_constellation(symbols, cons):
          # print("symbols:")
          # print(symbols)
          # print("points:")
          # print(cons.points())
          l = list(map(lambda x: cons.points()[x], symbols))
          # print("Training Symbols")
          # print(l)
          return l
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import random
  states: {}
- name: import_0_1
  id: import
  parameters:
    imports: from cmath import exp, pi
  states: {}
- name: import_0_2
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: prbs_bert_sink_b_0
  id: prbs_bert_sink_b
  parameters:
    g_data_invert: '0'
    g_meas_per_sec: '2'
    g_pn_sel: '1'
    g_samp_rate: samp_rate
    g_sync_bits: '511'
    g_total_bits: '10000'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    alpha2: '1'
    alpha3: '0.3'
    color3: '"black"'
    grid: 'True'
    gui_hint: 2,0,10,10
    label1: Synced
    label2: Synced & Equalized
    label3: Equalized & Phase Locked
    name: Synced Constellation
    nconnections: '3'
    size: '1024'
    type: complex
    width2: '2'
    width3: '2'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: 12,0,10,20
    label1: Transmitted & Propagated
    name: Transmitted & Received Spectrum
    type: complex
    ymax: '-10'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,10,10,10
    label1: Recovered Data
    name: Demodulated Bitstream
    size: '100'
    srate: '1'
    type: float
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: sdrplay3_rsp2_0
  id: sdrplay3_rsp2
  parameters:
    AGC: 'True'
    agc_set_point: '-30'
    antenna: Antenna A
    bandwidth: '0'
    biasT: 'False'
    center_freq: freq
    dc_offset_mode: 'False'
    debug_mode: 'False'
    freq_corr: '0'
    if_gRdB: '40'
    iq_balance_mode: 'False'
    output_type: fc32
    rf_gRLNA: '0'
    rf_gR_mode: dB
    rf_gRdB: '0'
    rf_notch_filter: 'False'
    rsp_selector: ''
    sample_rate: samp_rate
    sample_sequence_gaps_check: 'False'
    show_gain_changes: 'False'
    synchronous_updates: 'False'
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_agc_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_char_to_float_0_0, '0', blocks_float_to_int_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_float_to_int_0, '0', prbs_bert_sink_b_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', digital_probe_mpsk_snr_est_c_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '2']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_linear_equalizer_0_0, '0', digital_costas_loop_cc_0, '0']
- [digital_linear_equalizer_0_0, '0', qtgui_const_sink_x_0, '1']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_probe_mpsk_snr_est_c_0, snr, blocks_message_debug_0, print]
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0, '0']
- [sdrplay3_rsp2_0, '0', analog_agc_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
